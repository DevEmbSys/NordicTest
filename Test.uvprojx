# Keil uVision project Test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.29.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Test
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c include: .\User;.\components\ble\common;.\components\ble\nrf_ble_gatt;.\components\ble\nrf_ble_qwr;.\components\libraries\util;.\config;.\components\softdevice\s132\headers;.\components\softdevice\common;.\components\libraries\experimental_section_vars;.\integration\nrfx;.\components\libraries\strerror;.\components\libraries\atomic;.\components\libraries\timer;.\components\libraries\log;.\components\libraries\log\src;.\components\libraries\atomic_flags;.\components\libraries\atomic_fifo;.\components\libraries\sortlist;.\modules\nrfx;.\components\softdevice\s132\headers\nrf52;.\components\libraries\memobj;.\components\libraries\balloc;.\external\fprintf;.\components\libraries\ringbuf;.\integration\nrfx\legacy;.\modules\nrfx\drivers\include;.\components\boards;.\components\libraries\button;.\components\ble\ble_services\ble_lbs;.\components\libraries\pwr_mgmt;.\modules\nrfx\hal;.\components\libraries\mutex;.\components\libraries\delay
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xda000
  memory RVCT9: RAM 0x20002a98 size 0x3d568
  memory RVCT10: RAM 0x800000 size 0x10000
  group User
    ./User/: main.c
  group nRF_BLE
    ./components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ./components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ./components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ./components/ble/ble_services/ble_lbs/: ble_lbs.c
  group nRF_SoftDevice
    ./components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_Drivers
    ./modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c nrfx_gpiote.c
    ./integration/nrfx/legacy/: nrf_drv_uart.c
    ./modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ./components/libraries/timer/: app_timer2.c drv_rtc.c
    ./components/libraries/util/: app_error.c app_util_platform.c app_error_weak.c app_error_handler_keil.c
    ./components/libraries/atomic_flags/: nrf_atflags.c
    ./components/libraries/atomic_fifo/: nrf_atfifo.c
    ./components/libraries/atomic/: nrf_atomic.c
    ./components/libraries/strerror/: nrf_strerror.c
    ./external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ./components/libraries/ringbuf/: nrf_ringbuf.c
    ./components/libraries/memobj/: nrf_memobj.c
    ./components/libraries/balloc/: nrf_balloc.c
    ./components/libraries/sortlist/: nrf_sortlist.c
    ./components/libraries/experimental_section_vars/: nrf_section_iter.c
    ./components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ./components/libraries/button/: app_button.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.29.0
